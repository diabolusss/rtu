# IAR project LCD_Demo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_LPC_2478_STK; IAR_LPC_2468
  ICCARM.CCIncludePath2: app; board; modules
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LCD_Demo.srec
  ILINK.IlinkOutputFile: LCD_Demo.out
  ILINK.IlinkIcfFile: config\LPC2478_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    app/: Cursor.c hid_mouse.c logo.c main.c usb_dev_desc.c
  group board
    board/: sys.c
  group config
    config/: LPC2478_Flash.icf
  group Modules
    modules/: adc.c cantest.c exttest.c glcd_drv.c i2c0_drv.c LPC24xx_USB.c sdram_32M_16bit_drv.c smb380_drv.c touchscreen.c uart.c
